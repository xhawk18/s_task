# IAR project FMC_LD.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051 series Nuvoton M051 series (M052,M054,M058,M0516)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: LDROM=1
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: ..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; ..\..\..\..\libM051Series\StdDriver\inc; ..\..\..\..\LibM051Series\M051-LB_004_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: FMC_LD.bin
  ILINK.IlinkOutputFile: FMC_LD.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: LDROM
  ICCARM.CCOptLevel: 1
  group CMSIS Files
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
  group Library Files
    ../../../../LibM051Series/StdDriver/src/: retarget.c
  group Source Files
    ../: main_LD.c
