# IAR project FMC.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051 series Nuvoton M051 series (M052,M054,M058,M0516)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; $PROJ_DIR$..\..\..\..\..\libM051Series\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\LibM051Series\M051-LB_004_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$
  OBJCOPY.OOCOutputFile: FMC.bin
  ILINK.IlinkOutputFile: FMC.out
  ILINK.IlinkIcfFile: FMC.icf
  ILINK.IlinkExtraOptions: --image_input Release\Exe\FMC_LD.bin,loaderImageBase,.bin_image,4; --image_input dummy.bin,loaderImageLimit,.bin_image,4
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; ..\..\..\..\libM051Series\StdDriver\inc; ..\..\..\..\LibM051Series\M051-LB_004_Driver\inc
  ICCARM.CCOptLevel: 0
  ILINK.IlinkExtraOptions: --image_input Debug\Exe\FMC_LD.bin,loaderImageBase,.bin_image,4; --image_input dummy.bin,loaderImageLimit,.bin_image,4
  group CMSIS Files
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
  group Library Files
    ../../../../LibM051Series/StdDriver/src/: retarget.c
  group Source Files
    ../: main.c
