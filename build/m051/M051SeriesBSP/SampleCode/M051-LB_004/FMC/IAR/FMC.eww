<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\FMC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\FMC_LD.ewp</path>
  </project>
  <batchBuild/>
</workspace>


