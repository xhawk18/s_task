# IAR project I2C_24LC64.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: M051 series Nuvoton M051 series (M052,M054,M058,M0516)
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.CCIncludePath2: $PROJ_DIR$..\..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series; $PROJ_DIR$..\..\..\..\..\libM051Series\StdDriver\inc; $PROJ_DIR$..\..\..\..\..\LibM051Series\M051-LB_004_Driver\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: I2C_24LC64.bin
  ILINK.IlinkOutputFile: I2C_24LC64.out
  ILINK.IlinkIcfFile: M051Series.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCOptLevel: 0
  group CMSIS Files
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/iar/: startup_M051Series.s
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
  group Library Files
    ../../../../LibM051Series/M051-LB_004_Driver/src/: Ascii_Table.C EEPROM_24LC64.c LCD_Driver.c
    ../../../../LibM051Series/StdDriver/src/: retarget.c
  group Source Files
    ../../../Driver/UART/: IrDA.c LIN_Master.c RS485.c
    ../: main.c
