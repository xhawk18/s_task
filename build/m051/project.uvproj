# Keil uVision project project.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: s_task
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 uC99=1 wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST,NDEBUG
  c misc: --diag_error=warning
  c include: ..\..\include;.\M051SeriesBSP\LibM051Series\CMSIS\CM0\CoreSupport;.\M051SeriesBSP\LibM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;.\M051SeriesBSP\LibM051Series\StdDriver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ./M051SeriesBSP/LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c core_cm0.h
    ./M051SeriesBSP/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: M051Series.h system_M051Series.h system_M051Series.c
    ./M051SeriesBSP/LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group Driver
    ./M051SeriesBSP/LibM051Series/StdDriver/src/: retarget.c
  group Src
    ../../src/: s_list.c s_rbtree.c s_task.c s_event.c s_mutex.c s_timer_fast.c s_timer_small.c s_event_embed.c
    ../../examples/: ex1_event.c
  group Include
    ../../include/: s_list.h s_port_m051.h s_rbtree.h s_task.h
