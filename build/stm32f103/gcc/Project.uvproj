# Keil uVision project Project.uvproj, settings and files
target Project (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  group StdPeriph_Driver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_rcc.c stm32f10x_gpio.c misc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_fsmc.c stm32f10x_usart.c stm32f10x_sdio.c stm32f10x_dma.c stm32f10x_i2c.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_flash.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_tim.c stm32f10x_wwdg.c
  group CMSIS
    ../: system_stm32f10x.c
  group MDK-ARM
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/gcc_ride7/: startup_stm32f10x_md.s
  group Src
    ../: stm32f10x_it.c
    ../../../examples/: ex5_led_blinking.c
  group Include
    ../: stm32f10x_conf.h stm32f10x_it.h
  group s_task
    ../../../src/: s_list.c s_rbtree.c s_task.c s_event.c s_mutex.c s_timer_fast.c s_timer_small.c s_event_embed.c s_chan.c s_chan_embed.c
    ../../../include/: s_list.h s_port_stm32f10x.h s_rbtree.h s_task.h
