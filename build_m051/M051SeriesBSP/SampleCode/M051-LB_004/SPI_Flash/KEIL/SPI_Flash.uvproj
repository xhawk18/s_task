# Keil uVision project SPI_Flash.uvproj, settings and files
target SPI_Flash (ARM-ADS)
  device: M0516LAN Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0xFFFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: SPI_Flash
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: wLevel=2
  c define: DEBUG_ENABLE_SEMIHOST
  c include: ..\..\..\..\libM051Series\CMSIS\CM0\DeviceSupport\Nuvoton\M051Series;..\..\..\..\libM051Series\CMSIS\CM0\CoreSupport;..\..\..\..\libM051Series\StdDriver\inc;..\..\..\..\LibM051Series\M051-LB_004_Driver\inc
  asm define: DEBUG_ENABLE_SEMIHOST
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_M051Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS files
    ../../../../LibM051Series/CMSIS/CM0/CoreSupport/: core_cm0.c
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/: system_M051Series.c
    ../../../../LibM051Series/CMSIS/CM0/DeviceSupport/Nuvoton/M051Series/startup/arm/: startup_M051Series.s
  group Source files
    ../: main.c
  group Library files
    ../../../../LibM051Series/M051-LB_004_Driver/src/: Ascii_Table.C LCD_Driver.c SPIFLASH_Driver.c
    ../../../../LibM051Series/StdDriver/src/: retarget.c
