# IAR project project.ewp, settings and files
configuration Release (STM8)
  General.GenDeviceSelectMenu: STM8L051F3 STM8L051F3
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x0
  ICCSTM8.CCDefines: USE_STM8L1526_EVAL; STM8L05X_LD_VL; NDEBUG
  ICCSTM8.CCIncludePath2: ; ..\..\include; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Libraries\STM8L15x_StdPeriph_Driver\inc; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\STM8_EVAL; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\STM8_EVAL\STM8L1526_EVAL; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\STM8_EVAL\Common; STM8L15x-16x-05x-AL31-L_StdPeriph_Lib\Utilities\Misc
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: project.hex
  ILINK.IlinkOutputFile: project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (STM8, debug)
  as the first configuration, except:
  General.GenHeapSize: 0x4
  group s_task
    ../../src/: s_chan.c s_chan_embed.c s_event.c s_event_embed.c s_list.c s_mutex.c s_port_stm8l15x.inc s_rbtree.c s_task.c s_timer_fast.c s_timer_small.c s_uv.c
    ../../include/: s_list.h s_port_stm8l15x.h s_rbtree.h s_task.h s_task_internal.h s_uv.h
    ../../asm/: s_port_stm8.s
  group STM8L15x_StdPeriph_Driver
    STM8L15x-16x-05x-AL31-L_StdPeriph_Lib/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_aes.c stm8l15x_beep.c stm8l15x_clk.c stm8l15x_comp.c stm8l15x_dac.c stm8l15x_dma.c stm8l15x_exti.c stm8l15x_flash.c stm8l15x_gpio.c stm8l15x_i2c.c stm8l15x_irtim.c stm8l15x_itc.c stm8l15x_iwdg.c stm8l15x_lcd.c stm8l15x_pwr.c stm8l15x_rst.c stm8l15x_rtc.c stm8l15x_spi.c stm8l15x_syscfg.c stm8l15x_tim1.c stm8l15x_tim2.c stm8l15x_tim3.c stm8l15x_tim4.c stm8l15x_tim5.c stm8l15x_usart.c stm8l15x_wfe.c stm8l15x_wwdg.c
  group User
    ../../examples/: ex5_led_blinking.c
    ./: stm8l15x_conf.h stm8l15x_it.c stm8l15x_it.h
